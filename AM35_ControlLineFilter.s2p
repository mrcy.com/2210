!Agilent Technologies,E8364B,MY43040894,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Wednesday, September 12, 2018 13:49:16
!Correction: S11(Off)
!S21(Off)
!S12(Off)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 50 GHz, reference 50 ohm
!   highest |S21| = -22.83 dB at 10 MHz (marker M1); lowest = -70.9 dB at 9.852 GHz (marker M2)
!   lowest |S11| = -23.7 dB at 47.56 GHz (marker M3), VSWR 1.14, Z = 57 + j0.0731 ohm
!   |S11| at or under -10 dB: 11.41 GHz to 16.08 GHz (4.664 GHz wide, 33.9 % of centre); 17.09 GHz to 19.86 GHz (2.776 GHz wide, 15 % of centre); 40.13 GHz to end of sweep (the widest 3 of 6)
!   |S22| runs from -24.3 to -1.4 dB; largest |S21 - S12| = 0.023
!   the Smith chart shows 47.03 GHz to 48.41 GHz only
!   S11 on the Smith chart (normalised r, x): 47.03 GHz: 0.86, -0.21; 47.31 GHz: 1.00, +0.16; 47.69 GHz: 1.11, -0.10; 48.41 GHz: 0.95, -0.30
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -1.7  -22.8  -23.2  -1.4
! 1.104 GHz  -3.9  -52.0  -51.8  -3.6
! 2.26 GHz  -4.4  -65.6  -64.0  -4.1
! 8.352 GHz  -8.0  -67.8  -67.3  -7.7
! 9.852 GHz  -7.9  -70.9  -68.3  -7.0
! 16.69 GHz  -9.4  -56.6  -56.9  -11.5
! 19.1 GHz  -11.2  -56.0  -55.6  -12.0
! 20.57 GHz  -8.2  -58.1  -56.7  -24.2
! 21.72 GHz  -7.7  -59.4  -59.3  -13.2
! 25 GHz  -8.9  -58.6  -58.0  -9.8
! 33.35 GHz  -9.6  -62.6  -60.9  -13.2
! 38.47 GHz  -9.4  -48.1  -48.0  -8.4
! 40.69 GHz  -12.3  -55.9  -54.7  -17.1
! 41.69 GHz  -14.8  -60.1  -60.0  -9.9
! 43.97 GHz  -11.6  -56.8  -57.6  -15.8
! 45.69 GHz  -13.7  -42.0  -41.6  -11.7
! 47.03 GHz  -17.4  -39.1  -39.2  -13.6
! 47.31 GHz  -21.8  -39.8  -39.8  -14.9
! 47.56 GHz  -23.7  -40.9  -40.8  -15.6
! 47.69 GHz  -23.2  -41.7  -41.7  -15.5
! 48.41 GHz  -16.1  -49.7  -49.7  -14.6
! 50 GHz  -16.4  -41.3  -41.4  -14.5
