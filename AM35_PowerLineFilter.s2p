!Agilent Technologies,E8364B,MY43040894,A.07.50.67
!Agilent E8364B: A.07.50.67
!Date: Wednesday, September 12, 2018 13:48:32
!Correction: S11(Off)
!S21(Off)
!S12(Off)
!S22(Off)
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (low-pass shape):
!   1601 points, 10 MHz to 50 GHz, reference 50 ohm
!   highest |S21| = -0.89 dB at 10 MHz (marker M1); lowest = -64.0 dB at 39.94 GHz (marker M2)
!   |S21| within 3 dB of the highest: start of sweep to 690.7 MHz
!   lowest |S11| = -19.5 dB at 38.16 GHz (marker M3), VSWR 1.24, Z = 41.4 + j4.63 ohm
!   |S11| at or under -10 dB: start of sweep to 363.7 MHz; 31.49 GHz to 32.49 GHz (1.002 GHz wide, 3.13 % of centre); 37.34 GHz to end of sweep
!   |S22| runs from -19.4 to -3.2 dB; largest |S21 - S12| = 0.3
!   the Smith chart shows 37.94 GHz to 38.41 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -16.0  -0.9  -0.8  -15.3
! 1.229 GHz  -3.5  -6.2  -6.1  -3.3
! 3.853 GHz  -3.5  -13.0  -13.0  -7.0
! 6.602 GHz  -3.5  -38.3  -38.5  -3.2
! 8.352 GHz  -3.8  -47.8  -48.0  -3.6
! 14.85 GHz  -4.6  -52.2  -52.3  -5.5
! 16.69 GHz  -5.7  -46.9  -47.2  -5.2
! 20.82 GHz  -5.3  -53.6  -53.4  -5.2
! 25 GHz  -7.5  -44.1  -44.3  -6.6
! 29.1 GHz  -6.6  -58.3  -58.0  -6.2
! 32.19 GHz  -12.4  -44.3  -43.8  -7.1
! 33.35 GHz  -7.2  -48.6  -48.4  -8.8
! 36.88 GHz  -7.5  -53.3  -53.2  -6.9
! 38.16 GHz  -19.5  -47.2  -47.1  -8.2
! 39.03 GHz  -13.6  -51.0  -51.1  -8.7
! 39.94 GHz  -15.0  -64.0  -63.2  -10.3
! 40.78 GHz  -16.4  -49.3  -49.4  -13.2
! 41.69 GHz  -11.4  -49.8  -49.4  -9.0
! 43.66 GHz  -17.7  -43.7  -43.1  -8.6
! 46.31 GHz  -10.8  -29.7  -29.8  -14.4
! 47.09 GHz  -11.2  -28.7  -28.8  -19.4
! 50 GHz  -17.4  -25.5  -25.5  -15.5
